options:
  parameters:
    author: p01900
    generate_options: qt_gui
    id: DAQ_Demo_RHE_FFT
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: data_point_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: folder
  id: variable
  parameters:
    value: '"/home/p01900/nilm_at_fair/training_data/2022-11-16_training_data/"'
  states: {}
- name: items
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: low_pass_samp_rate
  id: variable
  parameters:
    value: (samp_rate / decimation)
  states: {}
- name: meas_type
  id: variable
  parameters:
    value: '"Mixed2_FFTSize131072"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: folder + "FFTApparentPower_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: folder + "FFTVoltage_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: folder + "FFTCurrent_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: folder + "P_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: folder + "Q_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: folder + "S_" + meas_type
    type: float
  states: {}
- name: blocks_file_sink_1_2
  id: blocks_file_sink
  parameters:
    file: folder + "Phi_" + meas_type
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '15'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 0.1 * samp_rate
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: 0.2 * samp_rate
    win: window.WIN_HANN
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 0.1 * samp_rate
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: 0.2 * samp_rate
    win: window.WIN_HANN
  states: {}
- name: pulsed_power_daq_picoscope_4000a_source_0
  id: pulsed_power_daq_picoscope_4000a_source
  parameters:
    acquisition_mode: Streaming
    buff_size: '204800'
    coupling_ai_a: '1'
    coupling_ai_b: '1'
    coupling_ai_c: '0'
    coupling_ai_d: '0'
    coupling_ai_e: '0'
    coupling_ai_f: '0'
    coupling_ai_g: '0'
    coupling_ai_h: '0'
    downsampling_factor: '1'
    downsampling_mode: '0'
    driver_buff_size: '102400'
    enable_ai_a: 'True'
    enable_ai_b: 'True'
    enable_ai_c: 'False'
    enable_ai_d: 'False'
    enable_ai_e: 'False'
    enable_ai_f: 'False'
    enable_ai_g: 'False'
    enable_ai_h: 'False'
    nr_buffers: '64'
    nr_waveforms: '5'
    offset_ai_a: '0.0'
    offset_ai_b: '0.0'
    offset_ai_c: '5.0'
    offset_ai_d: '0.0'
    offset_ai_e: '0.0'
    offset_ai_f: '0.0'
    offset_ai_g: '5.0'
    offset_ai_h: '0.0'
    poll_rate: '0.0005'
    post_samples: '10000'
    pre_samples: '500000'
    range_ai_a: '5'
    range_ai_b: '1'
    range_ai_c: '5.0'
    range_ai_d: '5.0'
    range_ai_e: '5'
    range_ai_f: '5'
    range_ai_g: '5.0'
    range_ai_h: '5.0'
    samp_rate: samp_rate
    serial_number: ''
    trigger_direction: '0'
    trigger_once: 'False'
    trigger_source: None
    trigger_threshold: '2.5'
  states: {}
- name: pulsed_power_daq_power_calc_ff_0
  id: pulsed_power_daq_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_daq_power_calc_ff_prepper_0
  id: pulsed_power_daq_power_calc_ff_prepper
  parameters:
    bp_decimation: '10'
    samp_rate: samp_rate_2
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"P"'
    size: '1024'
    srate: samp_rate_2
    type: float
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Q"'
    size: '1024'
    srate: samp_rate_2
    type: float
  states: {}
- name: qtgui_time_sink_x_3_1
  id: qtgui_time_sink_x
  parameters:
    name: '"S"'
    size: '1024'
    srate: samp_rate_2
    type: float
  states: {}
- name: qtgui_time_sink_x_3_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Phi"'
    size: '1024'
    srate: samp_rate_2
    type: float
  states: {}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    name: '"FFT Apparent Power"'
    size: fft_size
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_4_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FFT Voltage"'
    size: fft_size
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_4_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FFT Current"'
    size: fft_size
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_4, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', qtgui_time_sink_x_4_0, '0']
- [blocks_complex_to_mag_0_0_0_0_0, '0', blocks_file_sink_0_1_0_0, '0']
- [blocks_complex_to_mag_0_0_0_0_0, '0', qtgui_time_sink_x_4_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', fft_vxx_0_0_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_complex_to_mag_0_0_0_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', blocks_multiply_xx_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '1', blocks_null_sink_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '10', blocks_null_sink_0, '9']
- [pulsed_power_daq_picoscope_4000a_source_0, '11', blocks_null_sink_0, '10']
- [pulsed_power_daq_picoscope_4000a_source_0, '12', blocks_null_sink_0, '11']
- [pulsed_power_daq_picoscope_4000a_source_0, '13', blocks_null_sink_0, '12']
- [pulsed_power_daq_picoscope_4000a_source_0, '14', blocks_null_sink_0, '13']
- [pulsed_power_daq_picoscope_4000a_source_0, '15', blocks_null_sink_0, '14']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', blocks_multiply_xx_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', blocks_null_sink_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', blocks_stream_to_vector_0_0_0_0_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', filter_fft_low_pass_filter_0_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '3', blocks_null_sink_0, '2']
- [pulsed_power_daq_picoscope_4000a_source_0, '4', blocks_null_sink_0, '3']
- [pulsed_power_daq_picoscope_4000a_source_0, '5', blocks_null_sink_0, '4']
- [pulsed_power_daq_picoscope_4000a_source_0, '6', blocks_null_sink_0, '5']
- [pulsed_power_daq_picoscope_4000a_source_0, '7', blocks_null_sink_0, '6']
- [pulsed_power_daq_picoscope_4000a_source_0, '8', blocks_null_sink_0, '7']
- [pulsed_power_daq_picoscope_4000a_source_0, '9', blocks_null_sink_0, '8']
- [pulsed_power_daq_power_calc_ff_0, '0', blocks_file_sink_1, '0']
- [pulsed_power_daq_power_calc_ff_0, '0', blocks_null_sink_1_0_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '0', qtgui_time_sink_x_3, '0']
- [pulsed_power_daq_power_calc_ff_0, '1', blocks_file_sink_1_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '1', blocks_null_sink_1_0_0, '1']
- [pulsed_power_daq_power_calc_ff_0, '1', qtgui_time_sink_x_3_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '2', blocks_file_sink_1_1, '0']
- [pulsed_power_daq_power_calc_ff_0, '2', blocks_null_sink_1_0_0, '2']
- [pulsed_power_daq_power_calc_ff_0, '2', qtgui_time_sink_x_3_1, '0']
- [pulsed_power_daq_power_calc_ff_0, '3', blocks_file_sink_1_2, '0']
- [pulsed_power_daq_power_calc_ff_0, '3', blocks_null_sink_1_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '3', qtgui_time_sink_x_3_2, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '0', pulsed_power_daq_power_calc_ff_0, '2']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', pulsed_power_daq_power_calc_ff_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', pulsed_power_daq_power_calc_ff_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', blocks_null_sink_1_1, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', blocks_null_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
