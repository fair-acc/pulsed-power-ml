options:
  parameters:
    author: buchner
    generate_options: qt_gui
    id: three_phases_simulation
    output_language: cpp
    title: three_phases_simulation
  states: {}

blocks:
- name: analog_sig_source_x_0_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '325'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '325'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '325'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.2'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.2'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.2'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0_0_0_1
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0_0_1_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0_0_1_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1_1
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1_1_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1_1_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_divide_xx_0_0_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0_1_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1_1_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_1_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_0_0_0_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0_0_1_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0_0_1_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_1_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_1_1_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_1_1_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: bp_decimantion
  id: parameter
  parameters:
    label: band pass decimantion
    type: intx
    value: '20'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: current_correction_factor
  id: parameter
  parameters:
    label: Current Correction Factor
    type: eng_float
    value: '2.5'
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: in-coming samp rate
    type: eng_float
    value: '200000'
  states: {}
- name: low_pass_filter_0_1_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: lp_decimantion
  id: parameter
  parameters:
    label: low pass decimantion
    type: intx
    value: '1'
  states: {}
- name: out_samp_rate
  id: parameter
  parameters:
    label: out-going samp rate
    type: eng_float
    value: '10000'
  states: {}
- name: pulsed_power_daq_power_calc_mul_ph_ff_0_0
  id: pulsed_power_daq_power_calc_mul_ph_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: P_2
    label2: Q_2
    label3: S_2
    nconnections: '3'
    size: '1024'
    srate: out_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: P_1
    label2: Q_1
    label3: S_1
    nconnections: '3'
    size: '1024'
    srate: out_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: P_3
    label2: Q_3
    label3: S_3
    nconnections: '3'
    size: '1024'
    srate: out_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Phi_1
    label2: Phi_2
    label3: Phi_3
    nconnections: '3'
    size: '1024'
    srate: out_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: P_acc
    label2: Q_acc
    label3: S_acc
    nconnections: '3'
    size: '1024'
    srate: out_samp_rate
    type: float
  states: {}
- name: voltage_correction_factor
  id: parameter
  parameters:
    label: Voltage Correction Factor
    type: eng_float
    value: '100'
  states: {}

connections:
- [analog_sig_source_x_0_0_0_0_1, '0', blocks_multiply_xx_0_0_0_1, '1']
- [analog_sig_source_x_0_0_0_0_1, '0', blocks_multiply_xx_0_1_0_1, '1']
- [analog_sig_source_x_0_0_0_0_1_0, '0', blocks_multiply_xx_0_0_0_1_0, '1']
- [analog_sig_source_x_0_0_0_0_1_0, '0', blocks_multiply_xx_0_1_0_1_0, '1']
- [analog_sig_source_x_0_0_0_0_1_0_0, '0', blocks_multiply_xx_0_0_0_1_0_0, '1']
- [analog_sig_source_x_0_0_0_0_1_0_0, '0', blocks_multiply_xx_0_1_0_1_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', band_pass_filter_0_0_0_1, '0']
- [analog_sig_source_x_0_0_1_0, '0', band_pass_filter_0_0_0_1_0, '0']
- [analog_sig_source_x_0_0_1_0_0, '0', band_pass_filter_0_0_0_1_0_0, '0']
- [analog_sig_source_x_0_1_0_1, '0', blocks_multiply_xx_0_2_0_1, '1']
- [analog_sig_source_x_0_1_0_1, '0', blocks_multiply_xx_0_3_1, '1']
- [analog_sig_source_x_0_1_0_1_0, '0', blocks_multiply_xx_0_2_0_1_0, '1']
- [analog_sig_source_x_0_1_0_1_0, '0', blocks_multiply_xx_0_3_1_0, '1']
- [analog_sig_source_x_0_1_0_1_0_0, '0', blocks_multiply_xx_0_2_0_1_0_0, '1']
- [analog_sig_source_x_0_1_0_1_0_0, '0', blocks_multiply_xx_0_3_1_0_0, '1']
- [analog_sig_source_x_1_0_1, '0', band_pass_filter_0_1_1, '0']
- [analog_sig_source_x_1_0_1_0, '0', band_pass_filter_0_1_1_0, '0']
- [analog_sig_source_x_1_0_1_0_0, '0', band_pass_filter_0_1_1_0_0, '0']
- [band_pass_filter_0_0_0_1, '0', blocks_multiply_xx_0_1_0_1, '0']
- [band_pass_filter_0_0_0_1, '0', blocks_multiply_xx_0_3_1, '0']
- [band_pass_filter_0_0_0_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '6']
- [band_pass_filter_0_0_0_1_0, '0', blocks_multiply_xx_0_1_0_1_0, '0']
- [band_pass_filter_0_0_0_1_0, '0', blocks_multiply_xx_0_3_1_0, '0']
- [band_pass_filter_0_0_0_1_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '3']
- [band_pass_filter_0_0_0_1_0_0, '0', blocks_multiply_xx_0_1_0_1_0_0, '0']
- [band_pass_filter_0_0_0_1_0_0, '0', blocks_multiply_xx_0_3_1_0_0, '0']
- [band_pass_filter_0_0_0_1_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '0']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_0_0_1, '0']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_2_0_1, '0']
- [band_pass_filter_0_1_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '7']
- [band_pass_filter_0_1_1_0, '0', blocks_multiply_xx_0_0_0_1_0, '0']
- [band_pass_filter_0_1_1_0, '0', blocks_multiply_xx_0_2_0_1_0, '0']
- [band_pass_filter_0_1_1_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '4']
- [band_pass_filter_0_1_1_0_0, '0', blocks_multiply_xx_0_0_0_1_0_0, '0']
- [band_pass_filter_0_1_1_0_0, '0', blocks_multiply_xx_0_2_0_1_0_0, '0']
- [band_pass_filter_0_1_1_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '1']
- [blocks_divide_xx_0_0_0_1, '0', blocks_transcendental_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0_1_0, '0', blocks_transcendental_0_0_0_1_0, '0']
- [blocks_divide_xx_0_0_0_1_0_0, '0', blocks_transcendental_0_0_0_1_0_0, '0']
- [blocks_divide_xx_0_1_1, '0', blocks_transcendental_1_1, '0']
- [blocks_divide_xx_0_1_1_0, '0', blocks_transcendental_1_1_0, '0']
- [blocks_divide_xx_0_1_1_0_0, '0', blocks_transcendental_1_1_0_0, '0']
- [blocks_multiply_xx_0_0_0_1, '0', low_pass_filter_0_1_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_1_0, '0', low_pass_filter_0_1_0_0_1_0, '0']
- [blocks_multiply_xx_0_0_0_1_0_0, '0', low_pass_filter_0_1_0_0_1_0_0, '0']
- [blocks_multiply_xx_0_1_0_1, '0', low_pass_filter_0_1_1_0_1, '0']
- [blocks_multiply_xx_0_1_0_1_0, '0', low_pass_filter_0_1_1_0_1_0, '0']
- [blocks_multiply_xx_0_1_0_1_0_0, '0', low_pass_filter_0_1_1_0_1_0_0, '0']
- [blocks_multiply_xx_0_2_0_1, '0', low_pass_filter_0_1_2_0_1, '0']
- [blocks_multiply_xx_0_2_0_1_0, '0', low_pass_filter_0_1_2_0_1_0, '0']
- [blocks_multiply_xx_0_2_0_1_0_0, '0', low_pass_filter_0_1_2_0_1_0_0, '0']
- [blocks_multiply_xx_0_3_1, '0', low_pass_filter_0_1_3_1, '0']
- [blocks_multiply_xx_0_3_1_0, '0', low_pass_filter_0_1_3_1_0, '0']
- [blocks_multiply_xx_0_3_1_0_0, '0', low_pass_filter_0_1_3_1_0_0, '0']
- [blocks_sub_xx_0_0_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '8']
- [blocks_sub_xx_0_0_1_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '5']
- [blocks_sub_xx_0_0_1_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0_0, '2']
- [blocks_transcendental_0_0_0_1, '0', blocks_sub_xx_0_0_1, '1']
- [blocks_transcendental_0_0_0_1_0, '0', blocks_sub_xx_0_0_1_0, '1']
- [blocks_transcendental_0_0_0_1_0_0, '0', blocks_sub_xx_0_0_1_0_0, '1']
- [blocks_transcendental_1_1, '0', blocks_sub_xx_0_0_1, '0']
- [blocks_transcendental_1_1_0, '0', blocks_sub_xx_0_0_1_0, '0']
- [blocks_transcendental_1_1_0_0, '0', blocks_sub_xx_0_0_1_0_0, '0']
- [low_pass_filter_0_1_0_0_1, '0', blocks_divide_xx_0_0_0_1, '1']
- [low_pass_filter_0_1_0_0_1_0, '0', blocks_divide_xx_0_0_0_1_0, '1']
- [low_pass_filter_0_1_0_0_1_0_0, '0', blocks_divide_xx_0_0_0_1_0_0, '1']
- [low_pass_filter_0_1_1_0_1, '0', blocks_divide_xx_0_1_1, '1']
- [low_pass_filter_0_1_1_0_1_0, '0', blocks_divide_xx_0_1_1_0, '1']
- [low_pass_filter_0_1_1_0_1_0_0, '0', blocks_divide_xx_0_1_1_0_0, '1']
- [low_pass_filter_0_1_2_0_1, '0', blocks_divide_xx_0_0_0_1, '0']
- [low_pass_filter_0_1_2_0_1_0, '0', blocks_divide_xx_0_0_0_1_0, '0']
- [low_pass_filter_0_1_2_0_1_0_0, '0', blocks_divide_xx_0_0_0_1_0_0, '0']
- [low_pass_filter_0_1_3_1, '0', blocks_divide_xx_0_1_1, '0']
- [low_pass_filter_0_1_3_1_0, '0', blocks_divide_xx_0_1_1_0, '0']
- [low_pass_filter_0_1_3_1_0_0, '0', blocks_divide_xx_0_1_1_0_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '0', qtgui_time_sink_x_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '1', qtgui_time_sink_x_1, '1']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '10', qtgui_time_sink_x_0, '1']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '11', qtgui_time_sink_x_0, '2']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '12', qtgui_time_sink_x_2_0, '1']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '13', qtgui_time_sink_x_2, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '14', qtgui_time_sink_x_2, '1']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '2', qtgui_time_sink_x_2, '2']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '3', qtgui_time_sink_x_2_0, '2']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '4', qtgui_time_sink_x_2_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '5', qtgui_time_sink_x_2_1, '1']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '6', qtgui_time_sink_x_2_1, '2']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '7', qtgui_time_sink_x_1, '2']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '8', qtgui_time_sink_x_2_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0_0, '9', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
