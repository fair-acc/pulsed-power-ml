options:
  parameters:
    generate_options: qt_gui
    id: flowgraph_picoscope_three_phases
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: out_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_0_0_1
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1_1
  id: band_pass_filter
  parameters:
    decim: bp_decimantion
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '9'
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_0_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_0_0_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_1_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_1_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: bp_decimantion
  id: parameter
  parameters:
    label: band pass decimantion
    type: intx
    value: '20'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: current_correction_factor
  id: parameter
  parameters:
    label: Current Correction Factor
    type: eng_float
    value: '2.5'
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: in-coming samp rate
    type: eng_float
    value: '200000'
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimantion
    gain: '1'
    samp_rate: out_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: lp_decimantion
  id: parameter
  parameters:
    label: low pass decimantion
    type: intx
    value: '1'
  states: {}
- name: out_samp_rate
  id: parameter
  parameters:
    label: out-going samp rate
    type: eng_float
    value: '10000'
  states: {}
- name: pulsed_power_daq_power_calc_mul_ph_ff_0
  id: pulsed_power_daq_power_calc_mul_ph_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_opencmw_time_sink_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: active_power_1
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: active_power_2
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: active_power_3
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: reactive_power_1
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: reactive_power_2
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: reactive_power_3
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: acc_active_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: apparent_power_1
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: apparent_power_2
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: apparent_power_3
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: acc_reactive_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_3
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: phi_1
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_3_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: phi_2
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_3_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: phi_3
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_3_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: acc_apparent_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_4
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_1
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_4_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_2
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_4_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_3
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_bpf
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_bpf
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: voltage_bpf
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_6
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_1
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_6_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_2
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_6_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_3
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_7
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_bpf
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_7_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_bpf
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_7_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: samp_rate
    signal_name: current_bpf
    signal_unit: Ampere
  states: {}
- name: pulsed_power_picoscope_4000a_source_0
  id: pulsed_power_picoscope_4000a_source
  parameters:
    acquisition_mode: Streaming
    buff_size: '204800'
    coupling_ai_a: '1'
    coupling_ai_b: '1'
    coupling_ai_c: '0'
    coupling_ai_d: '0'
    coupling_ai_e: '0'
    coupling_ai_f: '0'
    coupling_ai_g: '0'
    coupling_ai_h: '0'
    downsampling_factor: '1'
    downsampling_mode: '0'
    driver_buff_size: '102400'
    enable_ai_a: 'True'
    enable_ai_b: 'True'
    enable_ai_c: 'False'
    enable_ai_d: 'False'
    enable_ai_e: 'False'
    enable_ai_f: 'False'
    enable_ai_g: 'False'
    enable_ai_h: 'False'
    nr_buffers: '64'
    nr_waveforms: '5'
    offset_ai_a: '0.0'
    offset_ai_b: '0.0'
    offset_ai_c: '5.0'
    offset_ai_d: '0.0'
    offset_ai_e: '0.0'
    offset_ai_f: '0.0'
    offset_ai_g: '5.0'
    offset_ai_h: '0.0'
    poll_rate: '0.0005'
    post_samples: '10000'
    pre_samples: '500000'
    range_ai_a: '5'
    range_ai_b: '1'
    range_ai_c: '5.0'
    range_ai_d: '5.0'
    range_ai_e: '5'
    range_ai_f: '5'
    range_ai_g: '5.0'
    range_ai_h: '5.0'
    samp_rate: samp_rate
    serial_number: EW413/152
    trigger_direction: '0'
    trigger_once: 'False'
    trigger_source: None
    trigger_threshold: '2.5'
  states: {}
- name: voltage_correction_factor
  id: parameter
  parameters:
    label: Voltage Correction Factor
    type: eng_float
    value: '100'
  states: {}

connections:
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_multiply_xx_0_1_0_0, '1']
- [analog_sig_source_x_0_0_0_0_1, '0', blocks_multiply_xx_0_0_0_1, '1']
- [analog_sig_source_x_0_0_0_0_1, '0', blocks_multiply_xx_0_1_0_1, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_2_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_3, '1']
- [analog_sig_source_x_0_1_0_0, '0', blocks_multiply_xx_0_2_0_0, '1']
- [analog_sig_source_x_0_1_0_0, '0', blocks_multiply_xx_0_3_0, '1']
- [analog_sig_source_x_0_1_0_1, '0', blocks_multiply_xx_0_2_0_1, '1']
- [analog_sig_source_x_0_1_0_1, '0', blocks_multiply_xx_0_3_1, '1']
- [band_pass_filter_0_0_0, '0', blocks_multiply_xx_0_1_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_multiply_xx_0_3, '0']
- [band_pass_filter_0_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '0']
- [band_pass_filter_0_0_0, '0', pulsed_power_opencmw_time_sink_5, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_multiply_xx_0_1_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_multiply_xx_0_3_0, '0']
- [band_pass_filter_0_0_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '3']
- [band_pass_filter_0_0_0_0, '0', pulsed_power_opencmw_time_sink_5_0, '0']
- [band_pass_filter_0_0_0_1, '0', blocks_multiply_xx_0_1_0_1, '0']
- [band_pass_filter_0_0_0_1, '0', blocks_multiply_xx_0_3_1, '0']
- [band_pass_filter_0_0_0_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '6']
- [band_pass_filter_0_0_0_1, '0', pulsed_power_opencmw_time_sink_5_1, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_2_0, '0']
- [band_pass_filter_0_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '1']
- [band_pass_filter_0_1, '0', pulsed_power_opencmw_time_sink_7, '0']
- [band_pass_filter_0_1_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [band_pass_filter_0_1_0, '0', blocks_multiply_xx_0_2_0_0, '0']
- [band_pass_filter_0_1_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '4']
- [band_pass_filter_0_1_0, '0', pulsed_power_opencmw_time_sink_7_0, '0']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_0_0_1, '0']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_2_0_1, '0']
- [band_pass_filter_0_1_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '7']
- [band_pass_filter_0_1_1, '0', pulsed_power_opencmw_time_sink_7_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_transcendental_0_0_0, '0']
- [blocks_divide_xx_0_0_0_0, '0', blocks_transcendental_0_0_0_0, '0']
- [blocks_divide_xx_0_0_0_1, '0', blocks_transcendental_0_0_0_1, '0']
- [blocks_divide_xx_0_1, '0', blocks_transcendental_0_1, '0']
- [blocks_divide_xx_0_1_0, '0', blocks_transcendental_0_1_0, '0']
- [blocks_divide_xx_0_1_1, '0', blocks_transcendental_0_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', band_pass_filter_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', band_pass_filter_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', band_pass_filter_0_1_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', band_pass_filter_0_0_0_1, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', low_pass_filter_0_1_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_1, '0', low_pass_filter_0_1_0_0_1, '0']
- [blocks_multiply_xx_0_1_0, '0', low_pass_filter_0_1_1_0, '0']
- [blocks_multiply_xx_0_1_0_0, '0', low_pass_filter_0_1_1_0_0, '0']
- [blocks_multiply_xx_0_1_0_1, '0', low_pass_filter_0_1_1_0_1, '0']
- [blocks_multiply_xx_0_2_0, '0', low_pass_filter_0_1_2_0, '0']
- [blocks_multiply_xx_0_2_0_0, '0', low_pass_filter_0_1_2_0_0, '0']
- [blocks_multiply_xx_0_2_0_1, '0', low_pass_filter_0_1_2_0_1, '0']
- [blocks_multiply_xx_0_3, '0', low_pass_filter_0_1_3, '0']
- [blocks_multiply_xx_0_3_0, '0', low_pass_filter_0_1_3_0, '0']
- [blocks_multiply_xx_0_3_1, '0', low_pass_filter_0_1_3_1, '0']
- [blocks_sub_xx_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '2']
- [blocks_sub_xx_0_0_0, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '5']
- [blocks_sub_xx_0_0_1, '0', pulsed_power_daq_power_calc_mul_ph_ff_0, '8']
- [blocks_transcendental_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_transcendental_0_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [blocks_transcendental_0_0_0_1, '0', blocks_sub_xx_0_0_1, '1']
- [blocks_transcendental_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_transcendental_0_1_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_transcendental_0_1_1, '0', blocks_sub_xx_0_0_1, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [low_pass_filter_0_1_0_0_0, '0', blocks_divide_xx_0_0_0_0, '1']
- [low_pass_filter_0_1_0_0_1, '0', blocks_divide_xx_0_0_0_1, '1']
- [low_pass_filter_0_1_1_0, '0', blocks_divide_xx_0_1, '1']
- [low_pass_filter_0_1_1_0_0, '0', blocks_divide_xx_0_1_0, '1']
- [low_pass_filter_0_1_1_0_1, '0', blocks_divide_xx_0_1_1, '1']
- [low_pass_filter_0_1_2_0, '0', blocks_divide_xx_0_0_0, '0']
- [low_pass_filter_0_1_2_0_0, '0', blocks_divide_xx_0_0_0_0, '0']
- [low_pass_filter_0_1_2_0_1, '0', blocks_divide_xx_0_0_0_1, '0']
- [low_pass_filter_0_1_3, '0', blocks_divide_xx_0_1, '0']
- [low_pass_filter_0_1_3_0, '0', blocks_divide_xx_0_1_0, '0']
- [low_pass_filter_0_1_3_1, '0', blocks_divide_xx_0_1_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '0', pulsed_power_opencmw_time_sink_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '1', pulsed_power_opencmw_time_sink_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '10', pulsed_power_opencmw_time_sink_2_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '11', pulsed_power_opencmw_time_sink_3_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '12', pulsed_power_opencmw_time_sink_1_1_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '13', pulsed_power_opencmw_time_sink_2_1_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '14', pulsed_power_opencmw_time_sink_3_1_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '2', pulsed_power_opencmw_time_sink_2, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '3', pulsed_power_opencmw_time_sink_3, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '4', pulsed_power_opencmw_time_sink_0_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '5', pulsed_power_opencmw_time_sink_1_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '6', pulsed_power_opencmw_time_sink_2_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '7', pulsed_power_opencmw_time_sink_3_0, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '8', pulsed_power_opencmw_time_sink_0_1, '0']
- [pulsed_power_daq_power_calc_mul_ph_ff_0, '9', pulsed_power_opencmw_time_sink_1_1, '0']
- [pulsed_power_picoscope_4000a_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '0', pulsed_power_opencmw_time_sink_4, '0']
- [pulsed_power_picoscope_4000a_source_0, '10', blocks_multiply_const_vxx_0_0_1, '0']
- [pulsed_power_picoscope_4000a_source_0, '10', pulsed_power_opencmw_time_sink_6_1, '0']
- [pulsed_power_picoscope_4000a_source_0, '11', blocks_null_sink_0, '4']
- [pulsed_power_picoscope_4000a_source_0, '12', blocks_null_sink_0, '5']
- [pulsed_power_picoscope_4000a_source_0, '13', blocks_null_sink_0, '6']
- [pulsed_power_picoscope_4000a_source_0, '14', blocks_null_sink_0, '7']
- [pulsed_power_picoscope_4000a_source_0, '15', blocks_null_sink_0, '8']
- [pulsed_power_picoscope_4000a_source_0, '2', blocks_multiply_const_vxx_0_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '2', pulsed_power_opencmw_time_sink_6, '0']
- [pulsed_power_picoscope_4000a_source_0, '3', blocks_null_sink_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '4', blocks_multiply_const_vxx_0_1, '0']
- [pulsed_power_picoscope_4000a_source_0, '4', pulsed_power_opencmw_time_sink_4_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '5', blocks_null_sink_0, '1']
- [pulsed_power_picoscope_4000a_source_0, '6', blocks_multiply_const_vxx_0_0_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '6', pulsed_power_opencmw_time_sink_6_0, '0']
- [pulsed_power_picoscope_4000a_source_0, '7', blocks_null_sink_0, '2']
- [pulsed_power_picoscope_4000a_source_0, '8', blocks_multiply_const_vxx_0_2, '0']
- [pulsed_power_picoscope_4000a_source_0, '8', pulsed_power_opencmw_time_sink_4_1, '0']
- [pulsed_power_picoscope_4000a_source_0, '9', blocks_null_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
