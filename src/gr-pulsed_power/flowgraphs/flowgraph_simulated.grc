options:
  parameters:
    author: johanna
    generate_options: qt_gui
    id: one_phase_simulated
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '325'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_delta_phi_calc
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_delta_phi_calc
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.2'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: in_samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: in_samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: bp_decimation
  id: parameter
  parameters:
    label: band pass decimation
    type: intx
    value: '200'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '10'
  states: {}
- name: decimation_long_term
  id: parameter
  parameters:
    label: Decimation Long Term
    type: eng_float
    value: '60000'
  states: {}
- name: decimation_mid_term
  id: parameter
  parameters:
    label: Decimation Mid Term
    type: eng_float
    value: '1000'
  states: {}
- name: decimation_short_term
  id: parameter
  parameters:
    label: Decimation Long Term
    type: eng_float
    value: '10'
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: in-coming samp rate
    type: eng_float
    value: '200000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '200'
    gain: '1'
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '200'
    gain: '1'
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_short_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_short_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_mid_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_long_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_short_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_mid_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_long_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_short_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_mid_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_long_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_4
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_mid_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_5
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: decimation_long_term
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '2000'
    gain: '1'
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '200000'
    gain: '1'
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '12000000'
    gain: '1'
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: lp_decimation
  id: parameter
  parameters:
    label: low pass decimation
    type: intx
    value: '1'
  states: {}
- name: out_samp_rate_high
  id: parameter
  parameters:
    label: Out Sample Rate High
    type: eng_float
    value: '1000'
  states: {}
- name: out_samp_rate_low
  id: parameter
  parameters:
    label: Out Sample Rate Low
    type: eng_float
    value: '100'
  states: {}
- name: pulsed_power_mains_frequency_calc_0
  id: pulsed_power_mains_frequency_calc
  parameters:
    expected_sample_rate: '200000'
    high_threshold: '100'
    low_threshold: '-100'
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '100'
    signal_name: active_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1'
    signal_name: active_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: 1/60
    signal_name: active_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '100'
    signal_name: reactive_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1'
    signal_name: reactive_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_1_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: 1/60
    signal_name: reactive_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '100'
    signal_name: apparent_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1'
    signal_name: apparent_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_2_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: 1/60
    signal_name: apparent_power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_3_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '100'
    signal_name: phi
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_3_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1'
    signal_name: phi
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_3_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: 1/60
    signal_name: phi
    signal_unit: rad
  states: {}
- name: pulsed_power_opencmw_time_sink_4
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1000'
    signal_name: voltage
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: out_samp_rate_high
    signal_name: voltage
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '100'
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1'
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: 1/60
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_6_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1000'
    signal_name: current
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_7_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    sample_rate: '1000'
    signal_name: current_bpf
    signal_unit: Ampere
  states: {}
- name: pulsed_power_power_calc_ff_0
  id: pulsed_power_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: samp_rate_delta_phi_calc
  id: parameter
  parameters:
    label: Sample Rate for Delta Phi Calculation
    type: eng_float
    value: '1000'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_2_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_3, '1']
- [analog_sig_source_x_1_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_multiply_xx_0_1_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_multiply_xx_0_3, '0']
- [band_pass_filter_0_0_0, '0', pulsed_power_opencmw_time_sink_5, '0']
- [band_pass_filter_0_0_0, '0', pulsed_power_power_calc_ff_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_2_0, '0']
- [band_pass_filter_0_1, '0', pulsed_power_opencmw_time_sink_7_0, '0']
- [band_pass_filter_0_1, '0', pulsed_power_power_calc_ff_0, '1']
- [blocks_divide_xx_0_0_0, '0', blocks_transcendental_0_0_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_transcendental_0_1, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_multiply_xx_0_1_0, '0', low_pass_filter_0_1_1_0, '0']
- [blocks_multiply_xx_0_2_0, '0', low_pass_filter_0_1_2_0, '0']
- [blocks_multiply_xx_0_3, '0', low_pass_filter_0_1_3, '0']
- [blocks_sub_xx_0_0, '0', pulsed_power_power_calc_ff_0, '2']
- [blocks_throttle_0, '0', band_pass_filter_0_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_throttle_0_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0_0, '0', pulsed_power_mains_frequency_calc_0, '0']
- [blocks_transcendental_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_transcendental_0_1, '0', blocks_sub_xx_0_0, '0']
- [low_pass_filter_0, '0', pulsed_power_opencmw_time_sink_4, '0']
- [low_pass_filter_0_0, '0', pulsed_power_opencmw_time_sink_6_0, '0']
- [low_pass_filter_0_1, '0', pulsed_power_opencmw_time_sink_1_0, '0']
- [low_pass_filter_0_1_0, '0', pulsed_power_opencmw_time_sink_2_0, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [low_pass_filter_0_1_0_1, '0', pulsed_power_opencmw_time_sink_2_0_0, '0']
- [low_pass_filter_0_1_0_2, '0', pulsed_power_opencmw_time_sink_2_0_1, '0']
- [low_pass_filter_0_1_1, '0', pulsed_power_opencmw_time_sink_3_0, '0']
- [low_pass_filter_0_1_1_0, '0', blocks_divide_xx_0_1, '1']
- [low_pass_filter_0_1_1_1, '0', pulsed_power_opencmw_time_sink_3_0_0, '0']
- [low_pass_filter_0_1_1_2, '0', pulsed_power_opencmw_time_sink_3_0_1, '0']
- [low_pass_filter_0_1_2, '0', pulsed_power_opencmw_time_sink_0_0, '0']
- [low_pass_filter_0_1_2_0, '0', blocks_divide_xx_0_0_0, '0']
- [low_pass_filter_0_1_2_1, '0', pulsed_power_opencmw_time_sink_0_0_0, '0']
- [low_pass_filter_0_1_2_2, '0', pulsed_power_opencmw_time_sink_0_0_1, '0']
- [low_pass_filter_0_1_3, '0', blocks_divide_xx_0_1, '0']
- [low_pass_filter_0_1_4, '0', pulsed_power_opencmw_time_sink_1_0_0, '0']
- [low_pass_filter_0_1_5, '0', pulsed_power_opencmw_time_sink_1_0_1, '0']
- [low_pass_filter_0_2, '0', pulsed_power_opencmw_time_sink_5_0, '0']
- [low_pass_filter_0_2_0, '0', pulsed_power_opencmw_time_sink_5_0_0, '0']
- [low_pass_filter_0_2_1, '0', pulsed_power_opencmw_time_sink_5_0_1, '0']
- [pulsed_power_mains_frequency_calc_0, '0', low_pass_filter_0_2, '0']
- [pulsed_power_mains_frequency_calc_0, '0', low_pass_filter_0_2_0, '0']
- [pulsed_power_mains_frequency_calc_0, '0', low_pass_filter_0_2_1, '0']
- [pulsed_power_power_calc_ff_0, '0', low_pass_filter_0_1_2, '0']
- [pulsed_power_power_calc_ff_0, '0', low_pass_filter_0_1_2_1, '0']
- [pulsed_power_power_calc_ff_0, '0', low_pass_filter_0_1_2_2, '0']
- [pulsed_power_power_calc_ff_0, '1', low_pass_filter_0_1, '0']
- [pulsed_power_power_calc_ff_0, '1', low_pass_filter_0_1_4, '0']
- [pulsed_power_power_calc_ff_0, '1', low_pass_filter_0_1_5, '0']
- [pulsed_power_power_calc_ff_0, '2', low_pass_filter_0_1_0, '0']
- [pulsed_power_power_calc_ff_0, '2', low_pass_filter_0_1_0_1, '0']
- [pulsed_power_power_calc_ff_0, '2', low_pass_filter_0_1_0_2, '0']
- [pulsed_power_power_calc_ff_0, '3', low_pass_filter_0_1_1, '0']
- [pulsed_power_power_calc_ff_0, '3', low_pass_filter_0_1_1_1, '0']
- [pulsed_power_power_calc_ff_0, '3', low_pass_filter_0_1_1_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
