options:
  parameters:
    author: johanna
    generate_options: qt_gui
    id: one_phase_simulated
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '325'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_delta_phi_calc
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '55'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_delta_phi_calc
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '50'
    offset: '0'
    phase: '0.2'
    samp_rate: in_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: bp_decimation
    gain: '1'
    high_cutoff_freq: bp_high_cut
    low_cutoff_freq: bp_low_cut
    samp_rate: in_samp_rate
    type: fir_filter_fff
    width: bp_trans
    win: window.WIN_HANN
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_2
  id: blocks_complex_to_mag
  parameters:
    vlen: '512'
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '20000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2000000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '120000000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_1
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_2
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_2_0
  id: blocks_keep_one_in_n
  parameters:
    n: '60000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_2_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '60000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_2_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: '60000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_2_0_2
  id: blocks_keep_one_in_n
  parameters:
    n: '60000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_3
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_3_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_3_1
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '2000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_2_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_3
  id: blocks_keep_one_in_n
  parameters:
    n: '4000'
    type: float
  states: {}
- name: blocks_keep_one_in_n_4
  id: blocks_keep_one_in_n
  parameters:
    type: float
  states: {}
- name: blocks_keep_one_in_n_5
  id: blocks_keep_one_in_n
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/512
    type: complex
    vlen: '512'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_1
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: in_samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: in_samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0_0_0
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_transcendental_0_1
  id: blocks_transcendental
  parameters:
    name: atan
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: bp_decimation
  id: parameter
  parameters:
    label: band pass decimation
    type: intx
    value: '2000'
  states: {}
- name: bp_high_cut
  id: parameter
  parameters:
    label: band pass high cutoff frequency
    type: eng_float
    value: '80'
  states: {}
- name: bp_low_cut
  id: parameter
  parameters:
    label: band pass low cutoff frequency
    type: eng_float
    value: '20'
  states: {}
- name: bp_trans
  id: parameter
  parameters:
    label: band pass transition width
    type: eng_float
    value: '1000'
  states: {}
- name: decimation_long_term
  id: parameter
  parameters:
    label: Decimation Long Term
    type: eng_float
    value: '60000'
  states: {}
- name: decimation_mid_term
  id: parameter
  parameters:
    label: Decimation Mid Term
    type: eng_float
    value: '1000'
  states: {}
- name: decimation_short_term
  id: parameter
  parameters:
    label: Decimation Long Term
    type: eng_float
    value: '10'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_2
  id: fft_vxx
  parameters:
    fft_size: '512'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.rectangular(512)
  states: {}
- name: in_samp_rate
  id: parameter
  parameters:
    label: in-coming samp rate
    type: eng_float
    value: '2000000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '10'
    gain: '1'
    samp_rate: '5000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: lp_decimation
    gain: '1'
    samp_rate: samp_rate_delta_phi_calc
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: lp_decimation
  id: parameter
  parameters:
    label: low pass decimation
    type: intx
    value: '1'
  states: {}
- name: out_samp_rate_high
  id: parameter
  parameters:
    label: Out Sample Rate High
    type: eng_float
    value: '1000'
  states: {}
- name: out_samp_rate_low
  id: parameter
  parameters:
    label: Out Sample Rate Low
    type: eng_float
    value: '100'
  states: {}
- name: pulsed_power_integration_0
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: MONTH
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_integration_0_0
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: DAY
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_integration_0_1
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: WEEK
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_integration_0_2
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: DAY
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_integration_0_3
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: WEEK
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_integration_0_4
  id: pulsed_power_integration
  parameters:
    decimation: '1000'
    duration: MONTH
    sample_rate: samp_rate_delta_phi_calc
  states: {}
- name: pulsed_power_mains_frequency_calc_0
  id: pulsed_power_mains_frequency_calc
  parameters:
    expected_sample_rate: in_samp_rate
    high_threshold: '100'
    low_threshold: '-100'
  states: {}
- name: pulsed_power_opencmw_freq_sink_0
  id: pulsed_power_opencmw_freq_sink
  parameters:
    bandwidth: in_samp_rate
    sample_rate: in_samp_rate
    signal_name: Apparent Power
    signal_unit: VA
    vector_size: '1'
  states: {}
- name: pulsed_power_opencmw_freq_sink_0_0
  id: pulsed_power_opencmw_freq_sink
  parameters:
    bandwidth: in_samp_rate
    sample_rate: in_samp_rate
    signal_name: Current
    signal_unit: A
    vector_size: '1'
  states: {}
- name: pulsed_power_opencmw_freq_sink_0_1
  id: pulsed_power_opencmw_freq_sink
  parameters:
    bandwidth: in_samp_rate
    sample_rate: in_samp_rate
    signal_name: Voltage
    signal_unit: V
    vector_size: '1'
  states: {}
- name: pulsed_power_opencmw_freq_sink_0_2
  id: pulsed_power_opencmw_freq_sink
  parameters:
    bandwidth: '50'
    sample_rate: '50'
    signal_name: Apparent Power
    signal_unit: VA
    vector_size: '512'
  states: {}
- name: pulsed_power_opencmw_time_sink_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '4'
    sample_rate: '100'
    signal_name: power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '4'
    sample_rate: '1'
    signal_name: power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_1_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '4'
    sample_rate: 1/60
    signal_name: power
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_2
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '12'
    sample_rate: '100'
    signal_name: power_stats
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_2_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '12'
    sample_rate: '1'
    signal_name: power_stats
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_0_2_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '12'
    sample_rate: 1/60
    signal_name: power_stats
    signal_unit: ''
  states: {}
- name: pulsed_power_opencmw_time_sink_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_0_2
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_0_3
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_0_4
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_0_5
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: S_Int
    signal_unit: Wh
  states: {}
- name: pulsed_power_opencmw_time_sink_4
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1000'
    signal_name: voltage
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: out_samp_rate_high
    signal_name: voltage
    signal_unit: Volt
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '100'
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1'
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_5_0_1
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: 1/60
    signal_name: mains_freq
    signal_unit: Hz
  states: {}
- name: pulsed_power_opencmw_time_sink_6_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1000'
    signal_name: current
    signal_unit: Ampere
  states: {}
- name: pulsed_power_opencmw_time_sink_7_0
  id: pulsed_power_opencmw_time_sink
  parameters:
    num_inputs: '1'
    sample_rate: '1000'
    signal_name: current_bpf
    signal_unit: Ampere
  states: {}
- name: pulsed_power_power_calc_ff_0
  id: pulsed_power_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_statistics_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_short_term
  states: {}
- name: pulsed_power_statistics_0_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_short_term
  states: {}
- name: pulsed_power_statistics_0_0_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_short_term
  states: {}
- name: pulsed_power_statistics_0_0_0_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_mid_term
  states: {}
- name: pulsed_power_statistics_0_0_0_0_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_long_term
  states: {}
- name: pulsed_power_statistics_0_0_1
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_short_term
  states: {}
- name: pulsed_power_statistics_0_0_1_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_mid_term
  states: {}
- name: pulsed_power_statistics_0_0_1_0_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_long_term
  states: {}
- name: pulsed_power_statistics_0_0_2
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_mid_term
  states: {}
- name: pulsed_power_statistics_0_0_2_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_long_term
  states: {}
- name: pulsed_power_statistics_0_1
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_mid_term
  states: {}
- name: pulsed_power_statistics_0_1_0
  id: pulsed_power_statistics
  parameters:
    decimation: decimation_long_term
  states: {}
- name: samp_rate_delta_phi_calc
  id: parameter
  parameters:
    label: Sample Rate for Delta Phi Calculation
    type: eng_float
    value: '1000'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_2_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_3, '1']
- [analog_sig_source_x_1_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_keep_one_in_n_4, '0']
- [band_pass_filter_0_0_0, '0', pulsed_power_opencmw_time_sink_5, '0']
- [band_pass_filter_0_1, '0', blocks_keep_one_in_n_5, '0']
- [band_pass_filter_0_1, '0', pulsed_power_opencmw_time_sink_7_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', pulsed_power_opencmw_freq_sink_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', pulsed_power_opencmw_freq_sink_0_0, '0']
- [blocks_complex_to_mag_0_0_0_1, '0', pulsed_power_opencmw_freq_sink_0_1, '0']
- [blocks_complex_to_mag_0_0_0_2, '0', pulsed_power_opencmw_freq_sink_0_2, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_transcendental_0_0_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_transcendental_0_1, '0']
- [blocks_keep_one_in_n_0, '0', pulsed_power_opencmw_time_sink_5_0, '0']
- [blocks_keep_one_in_n_0_0, '0', pulsed_power_opencmw_time_sink_5_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', pulsed_power_opencmw_time_sink_5_0_1, '0']
- [blocks_keep_one_in_n_1, '0', pulsed_power_opencmw_time_sink_0_0, '3']
- [blocks_keep_one_in_n_1_0, '0', pulsed_power_opencmw_time_sink_0_0_0_0, '3']
- [blocks_keep_one_in_n_1_1, '0', pulsed_power_opencmw_time_sink_0_0_0_0, '2']
- [blocks_keep_one_in_n_1_1_0, '0', pulsed_power_opencmw_time_sink_0_0_0_0, '1']
- [blocks_keep_one_in_n_1_2, '0', pulsed_power_opencmw_time_sink_0_0_0_0, '0']
- [blocks_keep_one_in_n_1_2_0, '0', pulsed_power_opencmw_time_sink_0_0_1_0, '0']
- [blocks_keep_one_in_n_1_2_0_0, '0', pulsed_power_opencmw_time_sink_0_0_1_0, '1']
- [blocks_keep_one_in_n_1_2_0_1, '0', pulsed_power_opencmw_time_sink_0_0_1_0, '3']
- [blocks_keep_one_in_n_1_2_0_2, '0', pulsed_power_opencmw_time_sink_0_0_1_0, '2']
- [blocks_keep_one_in_n_1_3, '0', pulsed_power_opencmw_time_sink_0_0, '1']
- [blocks_keep_one_in_n_1_3_0, '0', pulsed_power_opencmw_time_sink_0_0, '2']
- [blocks_keep_one_in_n_1_3_1, '0', pulsed_power_opencmw_time_sink_0_0, '0']
- [blocks_keep_one_in_n_2, '0', pulsed_power_opencmw_time_sink_4, '0']
- [blocks_keep_one_in_n_2_0, '0', pulsed_power_opencmw_time_sink_6_0, '0']
- [blocks_keep_one_in_n_3, '0', low_pass_filter_0, '0']
- [blocks_keep_one_in_n_4, '0', blocks_multiply_xx_0_1_0, '0']
- [blocks_keep_one_in_n_4, '0', blocks_multiply_xx_0_3, '0']
- [blocks_keep_one_in_n_4, '0', pulsed_power_power_calc_ff_0, '0']
- [blocks_keep_one_in_n_5, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_keep_one_in_n_5, '0', blocks_multiply_xx_0_2_0, '0']
- [blocks_keep_one_in_n_5, '0', pulsed_power_power_calc_ff_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0_0_0_2, '0']
- [blocks_multiply_xx_0, '0', blocks_keep_one_in_n_3, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_multiply_xx_0_1_0, '0', low_pass_filter_0_1_1_0, '0']
- [blocks_multiply_xx_0_2_0, '0', low_pass_filter_0_1_2_0, '0']
- [blocks_multiply_xx_0_3, '0', low_pass_filter_0_1_3, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_2, '0', fft_vxx_0_0_0_2, '0']
- [blocks_sub_xx_0_0, '0', pulsed_power_power_calc_ff_0, '2']
- [blocks_throttle_0, '0', band_pass_filter_0_1, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_2_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_keep_one_in_n_2, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_vector_0_0_0_1, '0']
- [blocks_throttle_0_0, '0', pulsed_power_mains_frequency_calc_0, '0']
- [blocks_transcendental_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_transcendental_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_mag_0_0_0_1, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_0_0_2, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0_0_0_2, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [low_pass_filter_0_1_1_0, '0', blocks_divide_xx_0_1, '1']
- [low_pass_filter_0_1_2_0, '0', blocks_divide_xx_0_0_0, '0']
- [low_pass_filter_0_1_3, '0', blocks_divide_xx_0_1, '0']
- [pulsed_power_integration_0, '0', pulsed_power_opencmw_time_sink_0, '0']
- [pulsed_power_integration_0_0, '0', pulsed_power_opencmw_time_sink_0_1, '0']
- [pulsed_power_integration_0_1, '0', pulsed_power_opencmw_time_sink_0_2, '0']
- [pulsed_power_integration_0_2, '0', pulsed_power_opencmw_time_sink_0_3, '0']
- [pulsed_power_integration_0_3, '0', pulsed_power_opencmw_time_sink_0_4, '0']
- [pulsed_power_integration_0_4, '0', pulsed_power_opencmw_time_sink_0_5, '0']
- [pulsed_power_mains_frequency_calc_0, '0', blocks_keep_one_in_n_0, '0']
- [pulsed_power_mains_frequency_calc_0, '0', blocks_keep_one_in_n_0_0, '0']
- [pulsed_power_mains_frequency_calc_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [pulsed_power_power_calc_ff_0, '0', blocks_keep_one_in_n_1_2, '0']
- [pulsed_power_power_calc_ff_0, '0', blocks_keep_one_in_n_1_2_0, '0']
- [pulsed_power_power_calc_ff_0, '0', blocks_keep_one_in_n_1_3_1, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_integration_0_0, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_integration_0_1, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_integration_0_4, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_statistics_0, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_statistics_0_1, '0']
- [pulsed_power_power_calc_ff_0, '0', pulsed_power_statistics_0_1_0, '0']
- [pulsed_power_power_calc_ff_0, '1', blocks_keep_one_in_n_1_1_0, '0']
- [pulsed_power_power_calc_ff_0, '1', blocks_keep_one_in_n_1_2_0_0, '0']
- [pulsed_power_power_calc_ff_0, '1', blocks_keep_one_in_n_1_3, '0']
- [pulsed_power_power_calc_ff_0, '1', pulsed_power_statistics_0_0, '0']
- [pulsed_power_power_calc_ff_0, '1', pulsed_power_statistics_0_0_2, '0']
- [pulsed_power_power_calc_ff_0, '1', pulsed_power_statistics_0_0_2_0, '0']
- [pulsed_power_power_calc_ff_0, '2', blocks_keep_one_in_n_1_1, '0']
- [pulsed_power_power_calc_ff_0, '2', blocks_keep_one_in_n_1_2_0_2, '0']
- [pulsed_power_power_calc_ff_0, '2', blocks_keep_one_in_n_1_3_0, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_integration_0, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_integration_0_2, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_integration_0_3, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_statistics_0_0_0, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_statistics_0_0_0_0, '0']
- [pulsed_power_power_calc_ff_0, '2', pulsed_power_statistics_0_0_0_0_0, '0']
- [pulsed_power_power_calc_ff_0, '3', blocks_keep_one_in_n_1, '0']
- [pulsed_power_power_calc_ff_0, '3', blocks_keep_one_in_n_1_0, '0']
- [pulsed_power_power_calc_ff_0, '3', blocks_keep_one_in_n_1_2_0_1, '0']
- [pulsed_power_power_calc_ff_0, '3', pulsed_power_statistics_0_0_1, '0']
- [pulsed_power_power_calc_ff_0, '3', pulsed_power_statistics_0_0_1_0, '0']
- [pulsed_power_power_calc_ff_0, '3', pulsed_power_statistics_0_0_1_0_0, '0']
- [pulsed_power_statistics_0, '0', pulsed_power_opencmw_time_sink_0_0_2, '0']
- [pulsed_power_statistics_0, '1', pulsed_power_opencmw_time_sink_0_0_2, '1']
- [pulsed_power_statistics_0, '2', pulsed_power_opencmw_time_sink_0_0_2, '2']
- [pulsed_power_statistics_0, '3', blocks_null_sink_0_0_1, '0']
- [pulsed_power_statistics_0_0, '0', pulsed_power_opencmw_time_sink_0_0_2, '3']
- [pulsed_power_statistics_0_0, '1', pulsed_power_opencmw_time_sink_0_0_2, '4']
- [pulsed_power_statistics_0_0, '2', pulsed_power_opencmw_time_sink_0_0_2, '5']
- [pulsed_power_statistics_0_0, '3', blocks_null_sink_0_0_1, '1']
- [pulsed_power_statistics_0_0_0, '0', pulsed_power_opencmw_time_sink_0_0_2, '6']
- [pulsed_power_statistics_0_0_0, '1', pulsed_power_opencmw_time_sink_0_0_2, '7']
- [pulsed_power_statistics_0_0_0, '2', pulsed_power_opencmw_time_sink_0_0_2, '8']
- [pulsed_power_statistics_0_0_0, '3', blocks_null_sink_0_0_1, '2']
- [pulsed_power_statistics_0_0_0_0, '0', pulsed_power_opencmw_time_sink_0_0_2_0, '6']
- [pulsed_power_statistics_0_0_0_0, '1', pulsed_power_opencmw_time_sink_0_0_2_0, '7']
- [pulsed_power_statistics_0_0_0_0, '2', pulsed_power_opencmw_time_sink_0_0_2_0, '8']
- [pulsed_power_statistics_0_0_0_0, '3', blocks_null_sink_0_0_1_0, '2']
- [pulsed_power_statistics_0_0_0_0_0, '0', pulsed_power_opencmw_time_sink_0_0_2_1, '6']
- [pulsed_power_statistics_0_0_0_0_0, '1', pulsed_power_opencmw_time_sink_0_0_2_1, '7']
- [pulsed_power_statistics_0_0_0_0_0, '2', pulsed_power_opencmw_time_sink_0_0_2_1, '8']
- [pulsed_power_statistics_0_0_0_0_0, '3', blocks_null_sink_0_0_1_1, '2']
- [pulsed_power_statistics_0_0_1, '0', pulsed_power_opencmw_time_sink_0_0_2, '9']
- [pulsed_power_statistics_0_0_1, '1', pulsed_power_opencmw_time_sink_0_0_2, '10']
- [pulsed_power_statistics_0_0_1, '2', pulsed_power_opencmw_time_sink_0_0_2, '11']
- [pulsed_power_statistics_0_0_1, '3', blocks_null_sink_0_0_1, '3']
- [pulsed_power_statistics_0_0_1_0, '0', pulsed_power_opencmw_time_sink_0_0_2_0, '9']
- [pulsed_power_statistics_0_0_1_0, '1', pulsed_power_opencmw_time_sink_0_0_2_0, '10']
- [pulsed_power_statistics_0_0_1_0, '2', pulsed_power_opencmw_time_sink_0_0_2_0, '11']
- [pulsed_power_statistics_0_0_1_0, '3', blocks_null_sink_0_0_1_0, '3']
- [pulsed_power_statistics_0_0_1_0_0, '0', pulsed_power_opencmw_time_sink_0_0_2_1, '9']
- [pulsed_power_statistics_0_0_1_0_0, '1', pulsed_power_opencmw_time_sink_0_0_2_1, '10']
- [pulsed_power_statistics_0_0_1_0_0, '2', pulsed_power_opencmw_time_sink_0_0_2_1, '11']
- [pulsed_power_statistics_0_0_1_0_0, '3', blocks_null_sink_0_0_1_1, '3']
- [pulsed_power_statistics_0_0_2, '0', pulsed_power_opencmw_time_sink_0_0_2_0, '3']
- [pulsed_power_statistics_0_0_2, '1', pulsed_power_opencmw_time_sink_0_0_2_0, '4']
- [pulsed_power_statistics_0_0_2, '2', pulsed_power_opencmw_time_sink_0_0_2_0, '5']
- [pulsed_power_statistics_0_0_2, '3', blocks_null_sink_0_0_1_0, '1']
- [pulsed_power_statistics_0_0_2_0, '0', pulsed_power_opencmw_time_sink_0_0_2_1, '3']
- [pulsed_power_statistics_0_0_2_0, '1', pulsed_power_opencmw_time_sink_0_0_2_1, '4']
- [pulsed_power_statistics_0_0_2_0, '2', pulsed_power_opencmw_time_sink_0_0_2_1, '5']
- [pulsed_power_statistics_0_0_2_0, '3', blocks_null_sink_0_0_1_1, '1']
- [pulsed_power_statistics_0_1, '0', pulsed_power_opencmw_time_sink_0_0_2_0, '0']
- [pulsed_power_statistics_0_1, '1', pulsed_power_opencmw_time_sink_0_0_2_0, '1']
- [pulsed_power_statistics_0_1, '2', pulsed_power_opencmw_time_sink_0_0_2_0, '2']
- [pulsed_power_statistics_0_1, '3', blocks_null_sink_0_0_1_0, '0']
- [pulsed_power_statistics_0_1_0, '0', pulsed_power_opencmw_time_sink_0_0_2_1, '0']
- [pulsed_power_statistics_0_1_0, '1', pulsed_power_opencmw_time_sink_0_0_2_1, '1']
- [pulsed_power_statistics_0_1_0, '2', pulsed_power_opencmw_time_sink_0_0_2_1, '2']
- [pulsed_power_statistics_0_1_0, '3', blocks_null_sink_0_0_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
