options:
  parameters:
    author: p01900
    generate_options: qt_gui
    id: DAQ_Demo_RHE_FFT
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: items
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: low_pass_samp_rate
  id: variable
  parameters:
    value: (samp_rate / decimation)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '15'
    type: float
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: items
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: low_pass_samp_rate
    shift: 'False'
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pulsed_power_daq_picoscope_4000a_source_0
  id: pulsed_power_daq_picoscope_4000a_source
  parameters:
    acquisition_mode: Streaming
    buff_size: '204800'
    coupling_ai_a: '1'
    coupling_ai_b: '1'
    coupling_ai_c: '0'
    coupling_ai_d: '0'
    coupling_ai_e: '0'
    coupling_ai_f: '0'
    coupling_ai_g: '0'
    coupling_ai_h: '0'
    downsampling_factor: '1'
    downsampling_mode: '0'
    driver_buff_size: '102400'
    enable_ai_a: 'True'
    enable_ai_b: 'True'
    enable_ai_c: 'False'
    enable_ai_d: 'False'
    enable_ai_e: 'False'
    enable_ai_f: 'False'
    enable_ai_g: 'False'
    enable_ai_h: 'False'
    nr_buffers: '64'
    nr_waveforms: '5'
    offset_ai_a: '0.0'
    offset_ai_b: '0.0'
    offset_ai_c: '5.0'
    offset_ai_d: '0.0'
    offset_ai_e: '0.0'
    offset_ai_f: '0.0'
    offset_ai_g: '5.0'
    offset_ai_h: '0.0'
    poll_rate: '0.0005'
    post_samples: '10000'
    pre_samples: '500000'
    range_ai_a: '5'
    range_ai_b: '1'
    range_ai_c: '5.0'
    range_ai_d: '5.0'
    range_ai_e: '5'
    range_ai_f: '5'
    range_ai_g: '5.0'
    range_ai_h: '5.0'
    samp_rate: samp_rate
    serial_number: ''
    trigger_direction: '0'
    trigger_once: 'False'
    trigger_source: None
    trigger_threshold: '2.5'
  states: {}
- name: pulsed_power_daq_power_calc_ff_0
  id: pulsed_power_daq_power_calc_ff
  parameters:
    alpha: '0.0001'
  states: {}
- name: pulsed_power_daq_power_calc_ff_prepper_0
  id: pulsed_power_daq_power_calc_ff_prepper
  parameters:
    bp_decimation: '20'
    samp_rate: '200000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: P
    label2: Q
    label3: S
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: Phi
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: Raw I
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: Raw U
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Frequency Spectrum"'
    vlen: items
    x_start: '0'
    x_step: '0.1'
    ymax: '60'
    ymin: '-20'
  states: {}

connections:
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [low_pass_filter_0_0, '0', logpwrfft_x_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '0', pulsed_power_daq_power_calc_ff_prepper_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '1', blocks_null_sink_0, '0']
- [pulsed_power_daq_picoscope_4000a_source_0, '10', blocks_null_sink_0, '9']
- [pulsed_power_daq_picoscope_4000a_source_0, '11', blocks_null_sink_0, '10']
- [pulsed_power_daq_picoscope_4000a_source_0, '12', blocks_null_sink_0, '11']
- [pulsed_power_daq_picoscope_4000a_source_0, '13', blocks_null_sink_0, '12']
- [pulsed_power_daq_picoscope_4000a_source_0, '14', blocks_null_sink_0, '13']
- [pulsed_power_daq_picoscope_4000a_source_0, '15', blocks_null_sink_0, '14']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', blocks_null_sink_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '2', pulsed_power_daq_power_calc_ff_prepper_0, '1']
- [pulsed_power_daq_picoscope_4000a_source_0, '3', blocks_null_sink_0, '2']
- [pulsed_power_daq_picoscope_4000a_source_0, '4', blocks_null_sink_0, '3']
- [pulsed_power_daq_picoscope_4000a_source_0, '5', blocks_null_sink_0, '4']
- [pulsed_power_daq_picoscope_4000a_source_0, '6', blocks_null_sink_0, '5']
- [pulsed_power_daq_picoscope_4000a_source_0, '7', blocks_null_sink_0, '6']
- [pulsed_power_daq_picoscope_4000a_source_0, '8', blocks_null_sink_0, '7']
- [pulsed_power_daq_picoscope_4000a_source_0, '9', blocks_null_sink_0, '8']
- [pulsed_power_daq_power_calc_ff_0, '0', qtgui_time_sink_x_0, '0']
- [pulsed_power_daq_power_calc_ff_0, '1', qtgui_time_sink_x_0, '1']
- [pulsed_power_daq_power_calc_ff_0, '2', qtgui_time_sink_x_0, '2']
- [pulsed_power_daq_power_calc_ff_0, '3', qtgui_time_sink_x_1, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '0', pulsed_power_daq_power_calc_ff_0, '2']
- [pulsed_power_daq_power_calc_ff_prepper_0, '1', pulsed_power_daq_power_calc_ff_0, '1']
- [pulsed_power_daq_power_calc_ff_prepper_0, '2', pulsed_power_daq_power_calc_ff_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '3', qtgui_time_sink_x_2, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', logpwrfft_x_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', low_pass_filter_0_0, '0']
- [pulsed_power_daq_power_calc_ff_prepper_0, '4', qtgui_time_sink_x_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
